# Repository Cocoas-Lab/Robocup-SSL-Circuit (continued)

## EAGLE design MotorDriver/MotorDriver.brd

Parts:
C4: 10n; C1005
C5: 47n; C1005
C6, C12, C13, C14, C16, C17, C18, C21, C25, C26, C27: 10u; C3225
C7, C19, C20, C22, C23, C24: 0.1u; C1005
C8: 4.7u; 1608
C9: 22n; C1005
CN5: T-CON
D7, D12: SBD-SOD523; DIODE_SOD523
D8, D9: SDM2U40CSP-7B; X3-WLB1608-2
D10: SMAJP4KE30A; DO-214AC
D13: TSPB20U80S S1G; SMPC
F1: 20; 3216
IC2: MAX3051ESA+; SOIC127P600X175-8N
IC3: TPD4S014DSQR; SON40P200X200X80-11N
IC6: LM5160QPWPRQ1; SOP65P640X110-15N
J1: J_USB_MICROAB_HIROSE_ZX62-AB-5PA
J2: SM03B-ZESS-TB
L1: 15u; L4949
LED0, LED3: RED; LED1608
LED1: GREEN; LED1608
LED2: WHITE; LED1608
R1: 120k; R1005
R2, R12, R21: 10k; R1005
R4, R5, R6, R32: 330; R1005
R8: 51k; R1005
R20: 22k; R1005
R22, R26, R27: 2.2k; R1005
R25: 3.3k; R1005
R28: 2.2; R1005
U3: MCP1700T-33; SOT23-3
U4: ADR5041; SC70-3

Connections:
!RST: D12.K; also elsewhere on the board
!USB_ACK: IC3.4 (!ACK), R12.1; also elsewhere on the board
+3V3: C19.1, C22.2, C23.2, C24.2, D7.A, IC2.3 (VCC), R12.2, R21.2, R32.2, U3.2 (VO); also elsewhere on the board
+5V: C20.1, D7.K, D8.1 (K), D9.1 (K), U3.3 (VI); also elsewhere on the board
CANH: IC2.7 (CANH), J2.2
CANL: IC2.6 (CANL), J2.3
CAN_RX: IC2.4 (RXD); also elsewhere on the board
CAN_TX: IC2.1 (TXD); also elsewhere on the board
D+: IC3.7 (D+), J1.P$3 (D+); also elsewhere on the board
D-: IC3.6 (D-), J1.P$2 (D-); also elsewhere on the board
GND: C5.1, C6.2, C7.1, C8.1, C9.1, C12.2, C13.2, C14.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.1, C23.1, C24.1, C25.2, C26.2, C27.2, CN5.N, D10.A, IC2.2 (GND), IC2.8 (RS), IC3.8 (GND), IC3.11 (CENTRAL_PAD_(GND)), IC6.1 (AGND), IC6.2 (PGND), IC6.15 (THERMAL_PAD_(AGND)), J1.P$5 (GND), J1.SHIELD1 (S1), J1.SHIELD2 (S2), J1.SHIELD3 (S3), J1.SHIELD4 (S4), LED3.K, R2.1, R4.1, R5.1, R6.1, R22.1, R26.1, R27.2, U3.1 (GND), U4.2 (A); also elsewhere on the board
LED0: LED0.A; also elsewhere on the board
LED1: LED1.A; also elsewhere on the board
LED2: LED2.A; also elsewhere on the board
unnamed: C7.2, IC6.8 (FPWM), IC6.10 (VCC)
unnamed: IC6.5 (RON), R8.2
unnamed: IC6.4 (EN/UVLO), R1.1, R2.2
unnamed: C9.2, IC6.6 (SS)
unnamed: LED2.K, R4.2
unnamed: LED0.K, R5.2
unnamed: LED1.K, R6.2
unnamed: IC3.9 (VBUS), IC3.10 (VBUS), J1.P$1 (VB)
unnamed: C4.1, IC6.12 (SW(1)), IC6.13 (SW(2)), L1.1
unnamed: IC6.9 (FB), R25.2, R27.1
unnamed: C4.2, IC6.11 (BST)
unnamed: C8.2, R28.2
unnamed: D13.1 (A), D13.2 (A), F1.1
unnamed: D12.A, J2.1
unnamed: D8.2 (A), L1.2, R25.1, R28.1
unnamed: IC3.3 (!EN), R26.2
unnamed: LED3.A, R32.1
SHDN: IC2.5 (SHDN); also elsewhere on the board
V+: C6.1, C12.1, C13.1, C14.1, C16.1, C17.1, C18.1, C21.1, C25.1, C26.1, C27.1, D10.K, D13.K, R20.2; also elsewhere on the board
VBAT: C5.2, R20.1, R22.2; also elsewhere on the board
VBAT/2: CN5.P, F1.2, IC6.3 (VIN), R1.2, R8.1
VBUS: D9.2 (A), IC3.1 (VBUSOUT), IC3.2 (VBUSOUT)
VREF: R21.1, U4.1 (K); also elsewhere on the board

Notes on the sheet:
3413.0330.22
SBDの記号だけどツェナー
VBAT= 1.09[V]@V+=12[V] 1.45[V]@V+=16[V] 2.18[V]@V+=24[V]
単方向リセット
250[mA]まで
1[Mbps]で動作 スルーレート制御なし
14～24[V] 9.6[V]以下はヒューズ切断と誤検知
35[V](margin 31.4[%])
Fsw_nominal -> 1[MHz]
Fsw = 980[kHz] @ Ron = 51[kohm]
Lmin = 10.2[uH]
deltaIL = 0.254[A] @ Vin = 19.2[V]
deltaIL = 0.272[A] @ Vin = 25.2[V]
ILpeak = 1.136[A] @ Io_max = 1.0[A]

Parts:
C1, C2, C3: 22u; C3225
C15, C28: 0.1u; C1005
C29, C31: 1u; C1005
C30: 47n; C1005
CN3: 43045-0800
D1, D2, D3, D4, D5, D6: SK34ATR; DO-214AC
IC4: DRV8320SRTVT; QFN50P500X500X80-33N
IC5: AS5601-ASOM; SOIC127P600X175-8N
Q1, Q2, Q3, Q4, Q5, Q6: BUK7Y3R5-40E; SOT669
R3, R13, R14, R15, R16, R17: 10; R1608
R19, R24: 2.2k; R1005

Connections:
!BRAKE: IC4.30 (INLC); also elsewhere on the board
!CS: IC4.21 (NSCS); also elsewhere on the board
!FAULT: IC4.17 (NFAULT); also elsewhere on the board
+3V3: C15.1, C28.1, IC5.1 (VDD5V), IC5.2 (VDD3V3), R19.2, R24.2; also elsewhere on the board
+5V: CN3.4; also elsewhere on the board
DIR: IC4.29 (INHC); also elsewhere on the board
GH_A: IC4.5 (GHA), R16.1
GH_B: IC4.12 (GHB), R14.1
GH_C: IC4.13 (GHC), R3.1
GL_A: IC4.7 (GLA), R17.1
GL_B: IC4.10 (GLB), R15.1
GL_C: IC4.15 (GLC), R13.1
GND: C1.2, C2.2, C3.2, C15.2, C28.2, C31.2, CN3.6, D2.A, D4.A, D6.A, IC4.8 (SLA), IC4.9 (SLB), IC4.16 (SLC), IC4.23 (AGND), IC4.31 (PGND), IC4.33 (THERMAL_PAD), IC5.4 (GND), Q2.1 (S), Q2.2 (S), Q2.3 (S), Q4.1 (S), Q4.2 (S), Q4.3 (S), Q6.1 (S), Q6.2 (S), Q6.3 (S); also elsewhere on the board
HALL_U: CN3.3, IC4.26 (INLA); also elsewhere on the board
HALL_V: CN3.2, IC4.27 (INHB); also elsewhere on the board
HALL_W: CN3.1, IC4.28 (INLB); also elsewhere on the board
unnamed: Q2.4 (G), R17.2
unnamed: Q1.4 (G), R16.2
unnamed: Q4.4 (G), R15.2
unnamed: Q3.4 (G), R14.2
unnamed: Q6.4 (G), R13.2
unnamed: Q5.4 (G), R3.2
unnamed: C31.1, IC4.24 (DVDD)
unnamed: C30.1, IC4.32 (CPL)
unnamed: C29.2, IC4.2 (VCP)
unnamed: C30.2, IC4.1 (CPH)
PWM_AH: IC4.25 (INHA); also elsewhere on the board
PWM_EN: IC4.22 (ENABLE); also elsewhere on the board
QEI_A: IC5.8 (A); also elsewhere on the board
QEI_B: IC5.5 (B); also elsewhere on the board
SCL: IC5.7 (SCL), R19.1; also elsewhere on the board
SCLK: IC4.20 (SCLK); also elsewhere on the board
SDA: IC5.6 (SDA), R24.1; also elsewhere on the board
SDI: IC4.19 (SDI); also elsewhere on the board
SDO: IC4.18 (SDO); also elsewhere on the board
SH_A: CN3.8, D1.A, D2.K, IC4.6 (SHA), Q1.1 (S), Q1.2 (S), Q1.3 (S), Q2.MB (D)
SH_B: CN3.7, D3.A, D4.K, IC4.11 (SHB), Q3.1 (S), Q3.2 (S), Q3.3 (S), Q4.MB (D)
SH_C: CN3.5, D5.A, D6.K, IC4.14 (SHC), Q5.1 (S), Q5.2 (S), Q5.3 (S), Q6.MB (D)
V+: C1.1, C2.1, C3.1, C29.1, D1.K, D3.K, D5.K, IC4.3 (VM), IC4.4 (VDRAIN), Q1.MB (D), Q3.MB (D), Q5.MB (D); also elsewhere on the board

Notes on the sheet:
C1210C106M6PACTU
22[uF]が欲しいけど在庫切れが著しいので暫定で10[uF]
35[V](margin 31.4[%])

Parts:
C10, C11: 10p; C1005
R7, R18, R23: 10k; R1005
SW1, SW2: SKRP
U1: LPC1549JBD48; QFP48
Y1: FA238V; EPSON_FA238V

Connections:
!BRAKE: U1.46 (PIO0_27/ACMP_I1); also elsewhere on the board
!CS: U1.7 (PIO0_6/ADC0_2/SCT2_OUT3); also elsewhere on the board
!FAULT: U1.13 (PIO0_18/SCT0_OUT5); also elsewhere on the board
!ISP: R7.1, SW2.A1, SW2.A2, U1.5 (PIO0_4/ADC0_4)
!RST: R23.1, SW1.A1, SW1.A2, U1.34 (RESET/PIO0_21); also elsewhere on the board
!USB_ACK: U1.22 (PIO0_14/ADC1_7/SCT1_OUT5); also elsewhere on the board
+3V3: R7.2, R18.1, R23.2, U1.16 (VDDA), U1.27 (VDD(1)), U1.30 (VBAT), U1.39 (VDD(2)), U1.42 (VDD(3)); also elsewhere on the board
CAN_RX: U1.29 (SWCLK/PIO0_19/TCK); also elsewhere on the board
CAN_TX: U1.28 (PIO0_17/WAKEUP/TRST); also elsewhere on the board
D+: U1.35 (USB_DP); also elsewhere on the board
D-: U1.36 (USB_DM); also elsewhere on the board
DIR: U1.47 (PIO0_28/ACMP1_I3); also elsewhere on the board
GND: C10.2, C11.2, SW1.B1, SW1.B2, SW2.B1, SW2.B2, U1.11 (VREFN), U1.17 (VSSA), U1.20 (VSS(1)), U1.31 (RTCXIN), U1.40 (VSS(2)), U1.41 (VSS(3)), Y1.2 (1), Y1.4 (1); also elsewhere on the board
HALL_U: U1.2 (PIO0_1/ADC0_7/SCT0_OUT4); also elsewhere on the board
HALL_V: U1.1 (PIO0_0/ADC0_10/SCT0_OUT3); also elsewhere on the board
HALL_W: U1.48 (PIO0_29/ACMP2_I3/SCT2_OUT4); also elsewhere on the board
LED0: U1.4 (PIO0_3/ADC0_5/SCT1_OUT4); also elsewhere on the board
LED1: U1.45 (PIO0_26/ACMP0_13/SCT3_OUT3); also elsewhere on the board
LED2: U1.44 (PIO0_25/ACMP0_14); also elsewhere on the board
unnamed: R18.2, U1.24 (PIO0_16/ADC1_9)
unnamed: C11.1, U1.25 (XTALOUT), Y1.1
unnamed: C10.1, U1.26 (XTALIN), Y1.3
PWM_AH: U1.3 (PIO0_2/ADC0_6/SCT1_OUT3); also elsewhere on the board
PWM_EN: U1.6 (PIO0_5/ADC0_3); also elsewhere on the board
QEI_A: U1.18 (PIO0_11/ADC1_3); also elsewhere on the board
QEI_B: U1.19 (PIO0_12/DAC_OUT); also elsewhere on the board
SCL: U1.37 (PIO0_22/I2C0_SCL); also elsewhere on the board
SCLK: U1.8 (PIO0_7/ADC0_1); also elsewhere on the board
SDA: U1.38 (PIO0_23/I2C0_SDA); also elsewhere on the board
SDI: U1.9 (PIO0_8/ADC0_O/TDO); also elsewhere on the board
SDO: U1.12 (PIO0_9/ADC1_1/TDI); also elsewhere on the board
SHDN: U1.23 (PIO0_15/ADC1_8); also elsewhere on the board
VBAT: U1.15 (PIO0_10/ADC1_2); also elsewhere on the board
VREF: U1.10 (VREFP_ADC), U1.14 (VREFP_DAC_VDDCMP); also elsewhere on the board

Notes on the sheet:
DFUはUSBしか使わないと仮定

Board: 2 copper layers, 50.0 x 50.0 mm, 96 parts (53 on the bottom side), 76 nets.

## Commit log

2017-10-03 Initial Commit
    Set up `.gitignore`
2017-10-03 Design circuit to drive motor.
2017-10-28 .epfの追跡をやめた
2017-10-28 KickerBoardの設計
    KIKSとの相違点
    ・動作電圧が50[V]まで
    ・LPCマイコン
    ・SPI接続
    ・充電電流の増加
    ・Fuse切断検出
2017-10-28 電源監視部分のLPF遮断周波数を下げた
2017-10-28 Descriptionを記述
2017-10-28 .gitignoreの編集
2017-10-28 とりあえず基板の形にしてみた
2017-10-28 '*_sch.pdf' と '*_brd.pdf' を無視するように
2017-10-28 ライブラリ用のリポジトリ
2017-10-28 Desctiptionの編集
2017-11-02 KickerBoardの部品表作成(途中)
2017-11-05 SCT1_OUT[5, 6]を使うために配線を入れ替えた
    1: PWM_CL->MOSI
    2: PWM_CH->RX
    22: RX->PWM_CH
    33 MOSI->PWM_CL
2017-11-11 FETのゲートソース間に抵抗を追加
2017-11-11 部品表を更新
2017-11-11 なんで.epfないん？
2017-11-11 なぜ私は.epfを日追跡にしてしまったの？
2017-12-08 nya-n
2018-01-02 無視リストを編集
    * `*.stp` と `*.lbr` は追跡しない
2018-01-02 機能追加 *CANバス *ホールセンサをダイレクトでDRVへ入力 *電源電圧監視 *DCDCをGDに内蔵 *15Aヒューズ
    機能削減
    *UART-DFUを廃止
    *SPI接続を廃止
2018-01-03 ヒューズ切断検出機能を追加
2018-01-23 USBラインの保護を強化した
2018-02-28 [fix]電源補助コンデンサの容量を小さくした
2018-02-28 [del]プルアップ/ダウン抵抗を除去
    *プルアップ/ダウンにはマイコンの機能を使用することにした
2018-03-01 メインとの通信をSPIからCANに切り替えた
2018-03-01 書き込み部・電源部を変更
    *書き込みをUARTからUSBに変更
    *USBコネクタを追加
    *12[MHz]クロックを追加
    *保護ICを追加
    *ピンヘッダを削除
    *5[V]電源の削除
2018-03-02 .epfが書き換わっていたので
2018-03-08 viaの数とかを調節した
2018-03-08 デバイス側で`id`を使ってUSBの接続を検出するのは不可能なので保護ICの`!ack`を使うように変更
2018-05-20 [fix]USB-ACKのプルアップ抵抗の変更とコメントの整理
2018-05-21 [fix] Kickerのコネクタのアサインを変更
2018-07-13 [add] schのpdfを追加
2018-07-13 [fix]DESCRIPTIONの編集
2018-07-31 [fix]仕様確定に伴って変更
    *電源電圧を24[V]に
    *エンコーダICが廃盤になったので変更
    *電源強化
    *部品票の更新
2018-07-31 [fix]部品表がいろいろおかしい
2018-08-19 [fix]キッカーボードを25[V]仕様に変更(部品表はまだ)
2018-08-19 [fix]pdfの更新
2018-08-19 これでコンフリクト回避できるかな
2018-09-09 [fix]ファイルが壊れてた
2019-12-03 tmpからもってきた
