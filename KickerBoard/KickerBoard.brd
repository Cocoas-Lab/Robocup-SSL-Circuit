# Repository Cocoas-Lab/Robocup-SSL-Circuit

## EAGLE design KickerBoard/KickerBoard.brd

Parts:
C2: 22n; C1005
C3, C9, C10, C11, C12: 0.1u; C1005
C4: 10n; C1005
C5: 220u; ES-6.3
C6, C8: 4.7u; C1608
C7: 0.22u; C1005
C22: 470p; C1005
CN1: T-CON
D1: SMAJP4KE30A; DO-214AC
D2, D11: SDM2U40CSP-7B; X3-WLB1608-2
D9: RB520S; DIODE_SOD523
F1: 15; 3216
L1: 15u; L4949
LED4: LED1608
R1: 130k; R1005
R2: 120k; R1005
R3, R5, R8: 10k; R1005
R4: 100; R1608
R6: 2k; R1005
R7: 2.2; R1608
R40: 33k; R1005
R41: 2.2k; R1005
R42: 330; R1005
U2: LM5160QPWPRQ1; SOP65P640X110-15N
U5: IC-AD_ADR5041; IC-AD_SC70-3
U11: ADCMP350YKSZ; KS_4
U12: MIC5219-3.3YMM; MSOP-8_MM

Connections:
+3V3: C12.1, D9.K, R8.2, U11.4 (VCC), U12.3 (OUT); also elsewhere on the board
+5V: D11.2 (A); also elsewhere on the board
+12V: C6.2, D2.2 (A), L1.2, R5.2, R7.2; also elsewhere on the board
FUSE: R42.2, U11.3 (OUT); also elsewhere on the board
GND: C2.2, C3.2, C5.N, C8.2, C9.2, C10.2, C11.2, C12.2, C22.2, CN1.N, D1.A, LED4.K, R3.1, R6.1, R41.1, U2.1 (AGND), U2.2 (PGND), U2.15 (THERMAL_PAD_(AGND)), U5.2 (A), U11.2 (GND), U12.5 (GND), U12.6 (GND), U12.7 (GND), U12.8 (GND); also elsewhere on the board
unnamed: C8.1, R7.1
unnamed: R2.2, U2.5 (RON)
unnamed: R1.1, R3.2, U2.4 (EN/UVLO)
unnamed: C2.1, U2.6 (SS)
unnamed: C3.1, U2.8 (FPWM), U2.10 (VCC)
unnamed: C4.1, U2.11 (BST)
unnamed: C4.2, L1.1, R4.1, U2.12 (SW(1)), U2.13 (SW(2))
unnamed: C6.1, C7.1, R4.2
unnamed: C7.2, R5.1, R6.2, U2.9 (FB)
unnamed: C11.1, D2.1 (K), D11.1 (K), U12.1 (EN), U12.2 (IN)
unnamed: D9.A, R40.1, R41.2, U11.1 (-)
unnamed: LED4.A, R42.1
unnamed: C22.1, U12.4 (BYP)
V+: C5.P, C9.1, C10.1, CN1.P, D1.K, F1.1, R1.2, R2.1, U2.3 (VIN)
VBAT: F1.2, R40.2; also elsewhere on the board
VREF: R8.1, U5.1 (K); also elsewhere on the board

Notes on the sheet:
Fsw_max=2.35[MHz]@20[V]
Fsw_max=3.18[MHz]@25[V]
->Fsw_nominal=1.00[MHz]
Vin_min=20.4[V] Vin_max=25.2[V]
Lmin=10[uH]@25[V]
deltaIL=320[mA]@20[V]
deltaIL=416[mA]@25[V]
IL_peak=1.71[A]
Resr>2.1[ohm]
Vhys=3.0[V]
Vth=19.8[V](3.3[V/cell])
Fuse切断検出回路
V_=0.6[V]@Vbat=9.6[V] V_=1.0[V]@Vbat=16[V] V_=3.1[V]@Vbat=50[V]
ASPIAIG-S6055-470M-T
Io=1.5[A]

Parts:
C23, C24: 10p; C1005
D12: SBD-SOD523; DIODE_SOD523
IC1: MAX3051ESA+; SOIC127P600X175-8N
IC2: TPD4S014DSQR; SON40P200X200X80-11N
J1: SM03B-ZESS-TB
J2: J_USB_MICROAB_HIROSE_ZX62-AB-5PA
LED1, LED2, LED3: LED1608
R15: 2.2k; 1608
R43, R44, R48, R49, R51: 10k; R1005
R45, R46, R47: 330; R1005
SW1, SW2: SKRP
U1: LPC1549JBD48; QFP48
Y1: FA238V; EPSON_FA238V

Connections:
!CUR_TRIP: U1.2 (PIO0_1/ADC0_7/SCT0_OUT4); also elsewhere on the board
!DISCHARGE: U1.4 (PIO0_3/ADC0_5/SCT1_OUT4); also elsewhere on the board
!ISP: R44.1, SW2.A1, SW2.A2, U1.5 (PIO0_4/ADC0_4)
!RST: D12.K, R43.1, SW1.A1, SW1.A2, U1.34 (RESET/PIO0_21)
+3V3: IC1.3 (VCC), R43.2, R44.2, R48.1, R49.2, U1.16 (VDDA), U1.27 (VDD(1)), U1.30 (VBAT), U1.39 (VDD(2)), U1.42 (VDD(3)); also elsewhere on the board
+5V: IC2.1 (VBUSOUT), IC2.2 (VBUSOUT); also elsewhere on the board
CAN_RX: IC1.4 (RXD), U1.23 (PIO0_15/ADC1_8)
CAN_TX: IC1.1 (TXD), U1.22 (PIO0_14/ADC1_7/SCT1_OUT5)
CURRENT_OUT: U1.8 (PIO0_7/ADC0_1); also elsewhere on the board
D+: IC2.7 (D+), J2.P$3 (D+), U1.35 (USB_DP)
D-: IC2.6 (D-), J2.P$2 (D-), U1.36 (USB_DM)
FUSE: U1.43 (PIO0_24/SCTO_OUT6); also elsewhere on the board
GATE_BOOST: U1.46 (PIO0_27/ACMP_I1); also elsewhere on the board
GATE_BUCK_H: U1.47 (PIO0_28/ACMP1_I3); also elsewhere on the board
GATE_BUCK_L: U1.48 (PIO0_29/ACMP2_I3/SCT2_OUT4); also elsewhere on the board
GATE_KICK1: U1.6 (PIO0_5/ADC0_3); also elsewhere on the board
GATE_KICK2: U1.9 (PIO0_8/ADC0_O/TDO); also elsewhere on the board
GND: C23.2, C24.2, IC1.2 (GND), IC1.8 (RS), IC2.8 (GND), IC2.11 (CENTRAL_PAD_(GND)), J2.P$5 (GND), J2.SHIELD1 (S1), J2.SHIELD2 (S2), J2.SHIELD3 (S3), J2.SHIELD4 (S4), LED1.K, LED2.K, LED3.K, R15.1, R51.1, SW1.B1, SW1.B2, SW2.B1, SW2.B2, U1.11 (VREFN), U1.17 (VSSA), U1.20 (VSS(1)), U1.31 (RTCXIN), U1.40 (VSS(2)), U1.41 (VSS(3)), Y1.2 (1), Y1.4 (1); also elsewhere on the board
LED1: R45.2, U1.33 (SWDIO/PIO0_20/SCT1_OUT6/TMS)
LED2: R46.2, U1.29 (SWCLK/PIO0_19/TCK)
LED3: R47.2, U1.28 (PIO0_17/WAKEUP/TRST)
unnamed: LED1.A, R45.1
unnamed: IC2.3 (!EN), R15.2
unnamed: IC1.5 (SHDN), R51.2
unnamed: LED2.A, R46.1
unnamed: LED3.A, R47.1
unnamed: C24.1, U1.26 (XTALIN), Y1.3
unnamed: C23.1, U1.25 (XTALOUT), Y1.1
unnamed: R48.2, U1.24 (PIO0_16/ADC1_9)
unnamed: IC1.6 (CANL), J1.3
unnamed: IC2.9 (VBUS), IC2.10 (VBUS), J2.P$1 (VB)
unnamed: IC1.7 (CANH), J1.2
unnamed: D12.A, J1.1
USBACK: IC2.4 (!ACK), R49.1, U1.13 (PIO0_18/SCT0_OUT5)
VOLT_BAT: U1.1 (PIO0_0/ADC0_10/SCT0_OUT3); also elsewhere on the board
VOLT_CAP: U1.7 (PIO0_6/ADC0_2/SCT2_OUT3); also elsewhere on the board
VOLT_CUR: U1.3 (PIO0_2/ADC0_6/SCT1_OUT3); also elsewhere on the board
VREF: U1.10 (VREFP_ADC), U1.14 (VREFP_DAC_VDDCMP); also elsewhere on the board

Parts:
C1: 0.47n; C1005
C13: 0.22u; C1005
C14: 0.1U; C1005
C15, C16, C17, C20: 0.1u; C1005
C18, C19: 10n; C1005
C21: 47n; C3216
D3: DIODE-DO-214AB; DO-214AB
D4: SMAJ300; DO-214AC
D5, D6: AS4PG; SMPC
D7, D8, D10: RB520S; DIODE_SOD523
JP1, JP2: 5569-02A2
L2: 8.2u; SRP6060FA220M
LED5: LED1608
Q1: TK12P60W; DPAK-3
Q2, Q3: IGBT-1N; TO-247AD_X1
Q4: BSS138; SOT23-3
Q5: BSP130; SOT223
Q6: ZXTN08400BFF; SOT23-3
R9: 2.4k; R1005
R10, R29, R31: 33k; R1005
R11, R21: 3.3k; R1005
R12: 2m; FC4L
R13, R14: 22; R1608
R16, R17, R18, R20, R23, R26, R27, R33, R37, R50: 10k; R1005
R19, R52, R53: 2.2; R1608
R22: 750; R1005
R24, R25, R34: 10; R1608
R28: 0.3m; WSL4026
R30: 2.2k; R1005
R32, R39: 1k; R1005
R35: 1.5M; R1005
R36: 2.2k; RIEDON-S-3
R38: 1.2M; R1005
U3: UCC27212DPRT; SON80P400X400X80-11N
U4: UCC27512DRSR; SON95P300X300X80-7N
U7: LT6108-2; MSOP8
U8: UCC27524DGN-NOPAD; MSOP8
U9: INA213; SC70-6
U10: AD8601; SOT23-5
U$1, U$2: AO4444; SOIC8

Connections:
!CUR_TRIP: R23.1, U7.3 (OUTC); also elsewhere on the board
!DISCHARGE: R34.2; also elsewhere on the board
+3V3: C17.1, C20.1, D7.K, D10.K, R23.2, U9.3 (V+), U10.5 (V+); also elsewhere on the board
+12V: C15.1, C16.1, U3.1 (VDD), U4.3 (VDD), U8.1 (ENA), U8.6 (VDD), U8.8 (ENB); also elsewhere on the board
CHARGE1: C21.1, D3.K, D4.K, D5.K, JP1.2
CHARGE2: D6.K, D8.K, JP2.2, LED5.A, R36.2, R38.2
CURRENT_NEG: R28.I1, U9.5 (VIN-)
CURRENT_OUT: U9.6 (OUT); also elsewhere on the board
CURRENT_POS: R28.I2, U9.4 (VIN+)
GATE_BOOST: U4.1 (IN+); also elsewhere on the board
GATE_BUCK_H: R18.2, U3.7 (HI); also elsewhere on the board
GATE_BUCK_L: R17.2, U3.8 (LI); also elsewhere on the board
GATE_KICK1: U8.2 (INA); also elsewhere on the board
GATE_KICK2: U8.4 (INB); also elsewhere on the board
GND: C1.2, C13.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, D4.A, Q1.3 (S), Q5.3 (S), R11.1, R16.1, R17.1, R18.1, R20.1, R22.1, R26.1, R27.1, R28.V1, R30.2, R32.1, R33.1, U3.9 (VSS), U3.11 (THERMAL_PAD), U4.2 (GND), U4.5 (GND), U4.6 (IN-), U4.7 (THERMAL_PAD), U7.4 (V-), U8.3 (GND), U9.1 (REF), U9.2 (GND), U10.2 (V-), U$2.1 (S), U$2.2 (S), U$2.3 (S); also elsewhere on the board
unnamed: R24.1, R26.2, U8.7 (OUTA)
unnamed: R9.2, R10.1, R11.2
unnamed: R10.2, R12.I1, R13.2, U7.2 (EN), U7.7 (V+)
unnamed: R13.1, U7.8 (SENSEHI)
unnamed: R29.2, R30.1, U10.4 (IN-)
unnamed: R14.1, U7.1 (SENSELO)
unnamed: R12.I2, R14.2
unnamed: R12.V2, U$1.5 (D), U$1.6 (D), U$1.7 (D), U$1.8 (D)
unnamed: R16.2, R53.1, U3.10 (LO)
unnamed: R50.2, R52.1, U3.3 (HO)
unnamed: C14.2, L2.1, R50.1, U3.4 (HS), U$1.1 (S), U$1.2 (S), U$1.3 (S), U$2.5 (D), U$2.6 (D), U$2.7 (D), U$2.8 (D)
unnamed: C14.1, U3.2 (HB)
unnamed: D3.A, L2.2, Q1.4 (D)
unnamed: R19.1, R20.2, U4.4 (OUT)
unnamed: Q1.1 (G), R19.2
unnamed: R25.1, R27.2, U8.5 (OUTB)
unnamed: R21.1, R22.2, U7.5 (INC)
unnamed: Q2.1 (G), R24.2
unnamed: Q3.1 (G), R25.2
unnamed: Q2.3 (E), Q3.3 (E), R28.V2
unnamed: D5.1 (A), D5.2 (A), JP1.1, Q2.2 (C)
unnamed: D7.A, R31.1, U10.3 (IN+)
unnamed: D6.1 (A), D6.2 (A), JP2.1, Q3.2 (C)
unnamed: C18.1, Q4.2 (S), R31.2, R32.2
unnamed: Q4.1 (G), R33.2, R34.1
unnamed: C19.1, Q4.3 (D), Q5.1 (G), R35.1
unnamed: Q5.2 (D), Q5.4 (D), R35.2, R36.1, R37.1, R39.1
unnamed: Q6.1 (B), R37.2, R38.1
unnamed: Q6.2 (E), R39.2
unnamed: D8.A, LED5.K, Q6.3 (C)
unnamed: R52.2, U$1.4 (G)
unnamed: R53.2, U$2.4 (G)
VBAT: R12.V1; also elsewhere on the board
VOLT_BAT: C13.1, R9.1; also elsewhere on the board
VOLT_CAP: R29.1, U10.1 (OUT); also elsewhere on the board
VOLT_CUR: C1.1, D10.A, R21.2, U7.6 (OUTA); also elsewhere on the board

Notes on the sheet:
Imax=6[A]
Vsense_max=12[mV]@I=6[A]
Iout_max=0.55[mA]@I=6]A]
Vout_max=2.21[V]@I=6[A]
Av=185 ((760+3.3k)/22)
Av=16 (1+33k/2.2k)
Vout=2.129[V]@Vcap=200[V]
Vout=1.597[V]@Vcap=150[V]
Vout=2.448[V]@Vcap=230[V]
541-1354-1-ND
Vc_max=235[V]
fc=332[Hz]
fc=83.6[kHz]
自動放電回路

Board: 2 copper layers, 75.0 x 50.0 mm, 126 parts (58 on the bottom side), 90 nets.

## EAGLE design MainBoard/MainBoard.brd

Parts:
C2, C3: 33p; C1608
C14: 0.1u; C1608
CN10: XBEE-TH
IC1: ESP-WROOM-02
R22: R1608
SW3: SKRP
U5: LPC1549JBD48; SOT313-2
U6: ESP-WROOM-32
Y1: CSTCE12M0G55-R0

Connections:
3.3V: U5.3 (PIO0_2/ADC0_6/SCT1_OUT3)
!MCLP: U5.2 (PIO0_1/ADC0_7/SCT0_OUT4); also elsewhere on the board
!RESET: C14.1, CN10.5 (!RESET), R22.1, SW3.B1, SW3.B2, U5.34 (!RESET!/PIO0_21)
+3V3: CN10.1 (VCC), IC1.1 (3V3), R22.2, U5.16 (VDDA), U5.27 (VDD), U5.39 (VDD), U5.42 (VDD), U6.2 (3V3); also elsewhere on the board
CAN0_RD: U5.21 (PIO0_13/ADC1_6); also elsewhere on the board
CAN0_TD: U5.13 (PIO0_18/SCT0_OUT5); also elsewhere on the board
D+: U5.35 (PIO2_12/USB_DP); also elsewhere on the board
D-: U5.36 (PIO2_13/USB_DM); also elsewhere on the board
DETECT: U5.48 (PIO0_29/ACMP2_I3/SCT2_OUT4); also elsewhere on the board
GND: C2.2, C3.2, C14.2, CN10.10 (GND), IC1.8 (IO0), IC1.9 (GND1), IC1.13 (GND2), IC1.18 (GND3), IC1.19 (GND0), SW3.A1, SW3.A2, U5.11 (VREFN), U5.17 (VSSA), U5.20 (VSS), U5.40 (VSS), U5.41 (VSS), U6.1 (GND), U6.15 (GND), U6.38 (GND), U6.GND, Y1.2 (GND); also elsewhere on the board
LSW1: U5.7 (PIO0_6/ADC0_2/SCT2_OUT3); also elsewhere on the board
LSW2: U5.8 (PIO0_7/ADC0_1); also elsewhere on the board
LSW3: U5.9 (PIO0_8/ADC0_0/TDO); also elsewhere on the board
unnamed: C2.1, U5.32 (RTCXOUT), Y1.1
unnamed: C3.1, U5.31 (RTCXIN), Y1.3
RX: U5.22 (PIO0_14/ADC1_7/SCT1_OUT5)
STBY: U5.4 (PIO0_3/ADC0_5/SCT1_OUT4); also elsewhere on the board
TX: U5.23 (PIO0_15/ADC1_8)
VBAT: U5.30 (VBAT)
VOLT_BAT: U5.1 (PIO0_0/ADC0_10/SCT0_OUT3); also elsewhere on the board
VREF: U5.10 (VREFP_ADC), U5.14 (VREFP_DAC_VDDCMP); also elsewhere on the board
XBEE_RX: CN10.2 (DOUT), IC1.11 (RXD), U5.19 (PIO0_12/DAC_OUT), U6.35 (TXD0)
XBEE_TX: CN10.3 (DIN/!CONFIG), IC1.12 (TXD), U5.18 (PIO0_11/ADC1_3), U6.34 (RXD0)

Parts:
C7, C8, C9: 220u; ES-12.5
C10, C11: 1u; C1608
C13, C16, C17, C18: C1608
C19, C20: 1u; C2012
CBP1, CBP2: 10u; C1608
CBST: 22n; C1608
CN1, CN2, CN3, CN4, CN5, CN6: T-CON
COUT1, COUT2: 22u; C1608
COUT3, COUT4, COUT5: 0.1u; C1608
D2: SBD-1608; DIODE_1608
D4: ZENER-DO-214AC; DO-214AC
D5: MBR230LSFT1G; SODFL3616X98N
F1, F2: 20; 3216
IC2: TS30042-M033QFNR; QFN50P300X300X100-17N
L2: SLF7045T-220MR90-PF; INDPM7070X480N
LED1: LED1608
Q1, Q2, Q3: NP52N06SLG-E2-AY; NP52N06SLGE2AY
R1, R2, R3, R4, R5, R6, R7, R11, R13, R14: 1k; R1608
R8: 10k; R1608
R9: 47k; R1608
R10: 2.2k; R1608
RBOT: 3k; R1608
RPLP: 10k; R1608
RTOP: 8k; R1608
SW1: SLE6A4; SLE6_10A4
U1: MCP1700T-33; SOT23-3
U2: ADR5041; SC70-3
U4, U7, U8: TLP185(GR,E(O; SOP254P700X220-4N

Connections:
+3V3: C11.1, C16.1, C17.1, C18.1, D2.A, U1.2 (VO); also elsewhere on the board
+5V: C10.1, C13.1, COUT1.1, COUT2.1, D2.K, L2.2, LED1.A, R8.2, RPLP.1, RTOP.1, U1.3 (VI); also elsewhere on the board
GND: C7.N, C8.N, C9.N, C10.2, C11.2, C13.2, C16.2, C17.2, C18.2, C19.2, C20.2, CBP1.2, CBP2.2, CN1.N, CN5.N, CN6.N, COUT1.2, COUT2.2, COUT3.2, COUT4.2, COUT5.2, D4.A, D5.2 (A), IC2.4 (GND), IC2.14 (PGND_1), IC2.16 (VSW_4), Q1.2 (S), Q2.2 (S), Q3.2 (S), R2.2, R3.2, R5.2, R6.2, R10.1, R11.2, R13.1, R14.2, RBOT.2, U1.1 (GND), U2.2 (A); also elsewhere on the board
KICKER: CN6.P, F2.2
LSW1: U4.1 (ANODE); also elsewhere on the board
LSW2: U7.1 (ANODE); also elsewhere on the board
LSW3: U8.1 (ANODE); also elsewhere on the board
unnamed: CN2.N, Q1.3 (D)
unnamed: R1.2, U4.3 (EMITTER)
unnamed: COUT5.1, Q1.1 (G), R1.1, R2.1
unnamed: CN3.N, Q2.3 (D)
unnamed: R3.1, U4.2 (CATHODE)
unnamed: R6.1, U7.2 (CATHODE)
unnamed: R4.1, U7.3 (EMITTER)
unnamed: CN4.N, Q3.3 (D)
unnamed: CN1.P, SW1.1 (B)
unnamed: CBST.1, D5.1 (K), IC2.1 (VSW_1), IC2.12 (VSW_2), IC2.13 (VSW_3), IC2.17 (PAD), L2.1
unnamed: COUT3.1, Q2.1 (G), R4.2, R5.1
unnamed: LED1.K, R13.2
unnamed: IC2.5 (FB), RBOT.1
unnamed: IC2.8 (PG), RPLP.2, RTOP.2
unnamed: CBST.2, IC2.10 (BST)
unnamed: R14.1, U8.2 (CATHODE)
unnamed: R7.1, U8.3 (EMITTER)
unnamed: COUT4.1, Q3.1 (G), R7.2, R11.1
V+: C7.P, C8.P, C9.P, C19.1, C20.1, CBP1.1, CBP2.1, D4.K, F1.1, F2.1, IC2.2 (VCC_1), IC2.3 (VCC_2), IC2.11 (VCC_3), R9.2, SW1.P (A)
VMOTOR: CN2.P, CN3.P, CN4.P, CN5.P, F1.2, U4.4 (COLLECTOR), U7.4 (COLLECTOR), U8.4 (COLLECTOR)
VOLT_BAT: R9.1, R10.2; also elsewhere on the board
VREF: R8.1, U2.1 (K); also elsewhere on the board

Notes on the sheet:
EMVY630ARA221MKE0S
VOLT_BAT=0.72[V]@16[V] VOLT_BAT=1.07[V]@24[V] VOLT_BAT=2.24[V]@50[V]
V+_min = 4.5[V] V+_max = 40[V]

Parts:
C1, C12: 0.1u; C1608
CN8: 53375-0410; 53375-04
D3: SBD-1608; 1608
GND: UX60SC-MB-5ST
IC3: MAX33053EASA+; SOIC127P605X145-8N
J1, J2, J3, J4, J5, J6: 53375-0310
LED9: LED1608
R12: 1k; R1608
R15, R16: 120; R1608

Connections:
!MCLP: J1.1, J2.1, J3.1, J4.1, J5.1, J6.1; also elsewhere on the board
+3.3V: IC3.5 (VL)
+3V3: CN8.2; also elsewhere on the board
+5V: CN8.1, D3.K; also elsewhere on the board
CAN0_RD: IC3.4 (RXD); also elsewhere on the board
CAN0_TD: IC3.1 (TXD); also elsewhere on the board
CANH: IC3.7 (CANH), J1.2, J2.2, J3.2, J4.2, J5.2, J6.2, R15.2, R16.1
CANL: IC3.6 (CANL), J1.3, J2.3, J3.3, J4.3, J5.3, J6.3, R15.1, R16.2
D+: GND.3 (D+); also elsewhere on the board
D-: GND.2 (D-); also elsewhere on the board
DETECT: CN8.3; also elsewhere on the board
GND: C1.2, C12.2, CN8.4, GND.5 (GND), GND.S1, GND.S2, IC3.2 (GND), R12.2; also elsewhere on the board
unnamed: C12.1, D3.A, GND.1 (VBUS), LED9.A
unnamed: LED9.K, R12.1
unnamed: C1.1, IC3.3 (VDD)
STBY: IC3.8 (S); also elsewhere on the board

Board: 2 copper layers, 75.0 x 50.0 mm, 84 parts (26 on the bottom side), 46 nets.

Notices in the files:
parts and their libraries:
NXP_60_26022015: This library may be distributed and adapted freely for any purpose, as long as NXP is credited and any new creation is licensed under the same terms.
